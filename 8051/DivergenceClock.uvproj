# Keil uVision project DivergenceClock.uvproj, settings and files
target Divergence Clock (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: DivergenceClock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51 main.c BCDCompute.c DS18B20.c DS1307.c Display.c ISD4004.c
  group Mode
    ./: TimeMode.c DateMode.c StopwatchMode.c WorldLineMode.c SetTimeMode.c SetDateMode.c MarqueeMode.c TemperatureMode.c UartMode.c
